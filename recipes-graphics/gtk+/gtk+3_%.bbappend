FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SRC_URI_append_riotboard = " file://addgles.patch "

PACKAGECONFIG = "wayland opengl"
